<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Access Point.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\End Device.ewp</path>
  </project>
  <batchBuild/>
</workspace>


