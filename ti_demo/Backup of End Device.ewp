# IAR project Backup of End Device.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 200
  General.GHeapSize2: 0
  ICC430.IExtraOptions: -f"Configuration\End Device\smpl_config.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: Components\bsp; Components\bsp\mcus; Components\bsp\drivers; Components\bsp\boards\EZ430RF; Components\mrfi; Components\SimpliciTI\nwk; Components\SimpliciTI\Network applications
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
  group Application
    ./: demo_ED.c vlo_rand.s43
  group Components
    lib/: SimpliciTI EZ430RF NWK ED Library.lib
  group Components/bsp
    Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    Components/simpliciti/nwk/: nwk_globals.c nwk_globals.h
  group Configuration
    Configuration/End Device/: smpl_config.dat
    Configuration/: smpl_nwk_config.dat
