# IAR project Backup of txrx_wsn.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 300
  General.GHeapSize2: 80
  ICC430.CCDefines: MRFI_CC2500
  ICC430.newCCIncludePaths: ..\drivers\bsp; ..\drivers\bsp\drivers; ..\drivers\bsp\boards\EZ430RF; ..\drivers\mrfi; ..\drivers\gradient
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group Application
    ../c_files/: txrx_wsn.c
  group Components/bsp
    ../drivers/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/gradient
    ../drivers/gradient/: gradient.c gradient.h printing.c printing.h QMgmt.c QMgmt.h sensing.c sensing.h wor.c wor.h
  group Components/mrfi
    ../drivers/mrfi/: mrfi.c mrfi.h mrfi_defs.h
